<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>May 29 19:25:02 2025</timestamp>
			<uuid>{e855416d-9453-4a53-8b30-8abd80e49868}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/mnt/vol_NFS_cadencedata/ESTUDIANTES/VLSI003/xh018_tut_env/tarea_3/Flipflop_tb/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/mnt/vol_NFS_cadencedata/ESTUDIANTES/VLSI003/xh018_tut_env/tarea_3/Flipflop_tb/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/mnt/vol_NFS_cadencedata/ESTUDIANTES/VLSI003/xh018_tut_env/Sim/tarea_3/Flipflop_tb/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/tarea_3/Flipflop_tb/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
